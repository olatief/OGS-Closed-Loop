# Keil uVision project closedLoop.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: closedLoop +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MCU_NRF24LE1
  c include: ..\..\hal\nrf24l01p;..\..\hal;..\..\compiler\c51;..\..\hal\nrf24le1
  group Source
    ./: STARTUP.A51 main.c hal_digipot.c timer.c led.c
  group HAL
    ../../hal/nrf24l01p/: hal_nrf.c
    ../../hal/nrf24le1/: hal_nrf_hw.c hal_spi.c hal_adc.c

# Keil uVision project le1_spipass.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: le1_spipass
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\hal\nrf24l01p;..\hal;..\compiler\c51;..\hal\nrf24le1;..\compiler\common
  group Source Group 1
    ./: STARTUP.A51
    ./le1 spi passthrough/: main.c
  group HAL
    ../hal/nrf24l01p/: hal_nrf.c
    ../hal/nrf24le1/: hal_spi.c hal_nrf_hw.c
